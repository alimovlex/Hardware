# Keil uVision project sd.uvprojx, settings and files
target Target 1 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: MDR1986BE91 Milandr
  pack: Keil.MDR1986BExx.1.5
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: sd
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: ..\sd4new;C:\Keil_v5\ARM\Pack\Keil\MDR1986BExx\1.4\Libraries\MDR32F9Qx_StdPeriph_Driver\inc;C:\Keil_v5\ARM\Pack\Keil\MDR1986BExx\1.4\Libraries\MDR32F9Qx_StdPeriph_Driver\src
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: main.c diskio.h ff.c ff.h ffconf.h integer.h mmc.c rtc.c rtc.h mlt_lcd.c rst.c Retarget.c joystick.c
    C:/Keil_v5/ARM/PACK/Keil/MDR1986BExx/1.5/Libraries/MDR32F9Qx_StdPeriph_Driver/src/: MDR32F9Qx_bkp.c
software components: Device:Startup 1.3.0, Drivers:PORT 1.3.0, Drivers:RST_CLK 1.3.0, Drivers:UART 1.3.0
